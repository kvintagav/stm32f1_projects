# Keil uVision project STM32_nRF24.uvprojx, settings and files
target STM32_nRF24_MASTER (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_nRF24_MASTER +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, MASTER
  c include: ..\..\Source\STM32F10x_StdPeriph_Driver\inc;..\..\Source\CMSIS;..\..\Source\library;..\..\Source\PeripheryConfig;..\test_nRF24;..\..\Source\library\ssd1306
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group SRC
    ./: main.c stm32f10x_it.c
  group Library
    ../../Source/library/: nRF24L01.c time.c CRC16_calculate.c
    ../../Source/library/ssd1306/: fonts.c ssd1306.c ssd1306_i2c.c
  group PeripheryConfig
    ../../Source/PeripheryConfig/: SPI_config.c
  group CMSIS
    ../../Source/CMSIS/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group STM32F10x_StdPeriph_Driver
    ../../Source/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
target STM32_nRF24_SLAVE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: STM32_nRF24 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F1XX, USE_STDPERIPH_DRIVER, STM32F10X_MD, SLAVE
  c include: ..\..\Source\STM32F10x_StdPeriph_Driver\inc;..\..\Source\CMSIS;..\..\Source\library;..\..\Source\PeripheryConfig;..\test_nRF24;..\..\Source\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
